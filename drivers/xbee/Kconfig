## drivers/xbee/Kconfig
```kconfig
# XBee Driver
# SPDX-License-Identifier: Apache-2.0

menuconfig XBEE
	bool "XBee Drivers"
```
